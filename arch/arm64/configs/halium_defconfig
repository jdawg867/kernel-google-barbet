## arch/arm64/configs/halium_defconfig
```kconfig
CONFIG_DEVTMPFS=y
CONFIG_FHANDLE=y
CONFIG_IPC_NS=y
CONFIG_NET_NS=y
CONFIG_UTS_NS=y
CONFIG_VT=y
```
